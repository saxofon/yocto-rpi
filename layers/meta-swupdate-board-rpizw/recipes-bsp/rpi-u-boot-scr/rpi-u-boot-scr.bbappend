FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

COMPATIBLE = "raspberrypi0-wifi"
