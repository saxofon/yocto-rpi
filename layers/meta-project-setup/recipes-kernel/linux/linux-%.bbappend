FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://disable-knfsd.cfg"
SRC_URI += "file://iio.cfg"
SRC_URI += "file://kernel-proc-configz.cfg"
#SRC_URI += "file://qemu-support.cfg"
