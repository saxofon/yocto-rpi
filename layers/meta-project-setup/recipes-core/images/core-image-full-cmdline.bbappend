IMAGE_INSTALL += "i2c-tools"
IMAGE_INSTALL += "iw"
IMAGE_INSTALL += "kernel-modules"
IMAGE_INSTALL += "linux-firmware-bcm43430"
IMAGE_INSTALL += "libiio"
IMAGE_INSTALL += "libiio-iiod"
IMAGE_INSTALL += "libiio-tests"
IMAGE_INSTALL += "openssh-sshd"
IMAGE_INSTALL += "raspi-gpio"
IMAGE_INSTALL += "strace"
IMAGE_INSTALL += "wireless-regdb-static"
