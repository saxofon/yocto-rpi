PACKAGECONFIG:append = " networkd resolved"

RDEPENDS_${PN}:append = " wpa-supplicant "

